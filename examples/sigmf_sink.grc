<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>sigm_sink</value></param>
<param><key>author</key><value>Kostis Triantafyllakis</value></param>
<param><key>description</key><value>A basic example of SigMF sink block</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>title</key><value>SigMF sink block</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_tags_strobe</key>
<param><key>id</key><value>blocks_tags_strobe_0</value></param>
<param><key>key</key><value>pmt.intern("capture")</value></param>
<param><key>nsamps</key><value>10000</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>value</key><value>pmt.PMT_T</value></param>
</block>
<block>
<key>blocks_tags_strobe</key>
<param><key>id</key><value>blocks_tags_strobe_0_0</value></param>
<param><key>key</key><value>pmt.intern("annotation")</value></param>
<param><key>nsamps</key><value>10000</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>value</key><value>pmt.dict_add(pmt.make_dict(), pmt.intern("sample_count"), pmt.from_long(100))</value></param>
</block>
<block>
<key>sigmf_sink</key>
<param><key>id</key><value>sigmf_sink_0</value></param>
<param><key>author</key><value>Kostis Triantafyllakis</value></param>
<param><key>datatype</key><value>cf32_l3</value></param>
<param><key>description</key><value>This is a test metadata file</value></param>
<param><key>metadata_filename</key><value>/home/ctriant/sigmf.json</value></param>
<param><key>hw</key><value></value></param>
<param><key>license</key><value></value></param>
<param><key>offset</key><value>0</value></param>
<param><key>sample_rate</key><value>0</value></param>
<param><key>sha512</key><value></value></param>
<param><key>version</key><value>0.0.1</value></param>
</block>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>sigmf_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tags_strobe_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tags_strobe_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
