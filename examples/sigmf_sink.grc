<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>sigmf_sink</value></param>
<param><key>author</key><value>Kostis Triantafyllakis</value></param>
<param><key>description</key><value>A basic example of SigMF sink block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>SigMF sink block</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>annot_comment</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>5, 0, 1, 1</value></param>
<param><key>label</key><value>Comment</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>annot_generator</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>4, 0, 1, 1</value></param>
<param><key>label</key><value>Generator</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>annotation_label</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>1, 0, 1, 1</value></param>
<param><key>label</key><value>Annotation</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>btn</value></param>
<param><key>value</key><value>False</value></param>
<param><key>gui_hint</key><value>6, 0, 1, 1</value></param>
<param><key>label</key><value>Add  Annotation</value></param>
<param><key>pressed</key><value>True</value></param>
<param><key>released</key><value>False</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>capture_label</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>1, 1, 1, 1</value></param>
<param><key>label</key><value>Capture</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_lower_edge</value></param>
<param><key>value</key><value>1e9</value></param>
<param><key>gui_hint</key><value>2, 0, 1, 1</value></param>
<param><key>label</key><value>Lower Frequency</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1e9</value></param>
<param><key>step</key><value>1e6</value></param>
<param><key>stop</key><value>4e9</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_range</value></param>
<param><key>value</key><value>2412e6</value></param>
<param><key>gui_hint</key><value>2, 1, 1, 1</value></param>
<param><key>label</key><value>UHD Rx Freq</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>2412e6</value></param>
<param><key>step</key><value>5e6</value></param>
<param><key>stop</key><value>2462e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_upper_edge</value></param>
<param><key>value</key><value>1e9</value></param>
<param><key>gui_hint</key><value>3, 0, 1, 1</value></param>
<param><key>label</key><value>Upper Frequency</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1e9</value></param>
<param><key>step</key><value>1e6</value></param>
<param><key>stop</key><value>4e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10e6</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_1</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>filter</key><value>"annotation_end"</value></param>
<param><key>name</key><value>Annotation</value></param>
</block>
<block>
<key>burst_tagger</key>
<param><key>id</key><value>burst_tagger_1</value></param>
<param><key>annotation_comment</key><value>annot_comment</value></param>
<param><key>generator</key><value>annot_generator</value></param>
<param><key>freq_lower_edge</key><value>freq_lower_edge</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>gate</key><value>btn</value></param>
<param><key>freq_upper_edge</key><value>freq_upper_edge</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>0,0,1,2</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>sigmf_sink</key>
<param><key>id</key><value>sigmf_sink_0</value></param>
<param><key>author</key><value>Kostis Triantafyllakis</value></param>
<param><key>comment</key><value>Field file refers to the full path including filename 
of the SigMF metadata file. Filename extension must
be .sigmf-meta. If not the block will force the change.</value></param>
<param><key>datatype</key><value>cf32_l3</value></param>
<param><key>description</key><value>This is a test metadata file</value></param>
<param><key>metadata_filename</key><value></value></param>
<param><key>hw</key><value></value></param>
<param><key>license</key><value></value></param>
<param><key>offset</key><value>0</value></param>
<param><key>sample_rate</key><value>0</value></param>
<param><key>sha512</key><value></value></param>
<param><key>version</key><value>0.0.1</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>test</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>test2</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>freq_range</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>35</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_add_xx_1</source_block_id><sink_block_id>burst_tagger_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>burst_tagger_1</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>burst_tagger_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>burst_tagger_1</source_block_id><sink_block_id>sigmf_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>test</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>test2</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>burst_tagger_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
