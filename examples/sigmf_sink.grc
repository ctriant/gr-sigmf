<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>sigm_sink</value></param>
<param><key>author</key><value>Kostis Triantafyllakis</value></param>
<param><key>description</key><value>A basic example of SigMF sink block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>SigMF sink block</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_range</value></param>
<param><key>value</key><value>1e9</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1e9</value></param>
<param><key>step</key><value>1e6</value></param>
<param><key>stop</key><value>4e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32e3</value></param>
</block>
<block>
<key>sigmf_sink</key>
<param><key>id</key><value>sigmf_sink_0</value></param>
<param><key>author</key><value>Kostis Triantafyllakis</value></param>
<param><key>datatype</key><value>cf32_l3</value></param>
<param><key>description</key><value>This is a test metadata file</value></param>
<param><key>metadata_filename</key><value></value></param>
<param><key>hw</key><value></value></param>
<param><key>license</key><value></value></param>
<param><key>offset</key><value>0</value></param>
<param><key>sample_rate</key><value>0</value></param>
<param><key>sha512</key><value></value></param>
<param><key>version</key><value>0.0.1</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>freq_range</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>35</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>sigmf_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
